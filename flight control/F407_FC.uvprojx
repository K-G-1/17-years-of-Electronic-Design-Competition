# Keil uVision project F407_FC.uvprojx, settings and files
target Anopilot (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407_FC
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --c99
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ./applications/: init.c include.h stm32f4xx_conf.h main.c stm32f4xx_it.c scheduler.c scheduler.h init.h parameter.c parameter.h ctrl.c ctrl.h imu.c imu.h mymath.c mymath.h data_transfer.c data_transfer.h rc.c rc.h usb_config.c usbd_user_hid.c version.c filter.c filter.h height_ctrl.c height_ctrl.h fly_mode.c fly_mode.h anotc_baro_ctrl.c anotc_baro_ctrl.h PID.c PID.h Trance.c Trance.h warn.c warn.h
  group Drivers
    ./drivers/: time.c time.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h i2c_soft.c i2c_soft.h mpu6050.c mpu6050.h led.c led.h ms5611.c ms5611.h usart.c usart.h usbd_STM32F4xx_FS.c drv_w25qxx.c ultrasonic.c ultrasonic.h ak8975.c VL53L0.c adc.c 24cxx.c 24cxx.h Ano_OF.c Ano_OF.h
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group USBStack
    ./Libraries/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group FatFs
    ./Libraries/FatFS/src/: diskio.c ff.c
  group Note
    ./doc/: note.txt record.txt
