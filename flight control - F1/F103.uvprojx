# Keil uVision project F103.uvprojx, settings and files
target ANO (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\applications;.\drivers;.\drivers\VL53L0;.\drivers\24CXX;.\Libraries\F1-CORE;.\Libraries;.\Libraries\STM32F10x_FWLib\inc;.\Libraries\FatFS;.\Libraries\FatFS\src;.\Libraries\F1-CORE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./applications/: include.h init.c init.h main.c scheduler.c scheduler.h parameter.c parameter.h ctrl.c ctrl.h imu.c imu.h mymath.c mymath.h data_transfer.c data_transfer.h rc.c rc.h version.c version.h filter.c filter.h height_ctrl.c height_ctrl.h fly_mode.c fly_mode.h anotc_baro_ctrl.c anotc_baro_ctrl.h PID.c PID.h Trance.c Trance.h warn.c warn.h inav.c
  group Devices
    ./drivers/: 24cxx.c 24cxx.h adc.c adc.h ak8975.c ak8975.h Ano_OF.c Ano_OF.h drv_w25qxx.c drv_w25qxx.h i2c_soft.c i2c_soft.h led.c led.h mpu6050.c mpu6050.h ms5611.c ms5611.h pwm_in.c pwm_in.h pwm_out.c pwm_out.h time.c time.h ultrasonic.c ultrasonic.h usart.c usart.h VL53L0.c VL53L0.h mpu9250.c mpu9250.h
  group CMSIS
    ./Libraries/F1-CORE/: core_cm3.c startup_stm32f10x_hd.s core_cm3.h
    ./Libraries/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group LIB
    ./Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group FATFS
    ./Libraries/FatFS/src/: diskio.h diskio.c ff.c ff.h ffconf.h integer.h
